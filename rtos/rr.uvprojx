# Keil uVision project rr.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rr
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: rr.c rr.h
  group lib
    ../../Downloads/lib/lib/: driverlib.lib
software components: RTOS:Config 11.2.0, RTOS:Core 11.2.0, RTOS:Event Groups 11.2.0, RTOS:Heap 11.2.0, RTOS:Timers 11.2.0, CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:FreeRTOS 11.2.0, Device:Startup 1.0.1
